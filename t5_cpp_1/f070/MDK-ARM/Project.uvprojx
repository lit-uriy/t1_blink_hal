# Keil uVision project Project.uvprojx, settings and files
target STM32F070RB-Nucleo (6140001::V6.14.1::ARMCLANG)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: out +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: STM32F070xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c include: ../Inc;../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../Drivers/BSP/STM32F0xx-Nucleo;../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal.c stm32f0xx_hal_dma.c stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c
  group Example/MDK-ARM
    ./: startup_stm32f070xb.s
  group Drivers/BSP/STM32F0xx-Nucleo
    ../../../Drivers/BSP/STM32F0xx-Nucleo/: stm32f0xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.cpp
software components: CMSIS:CORE 5.4.0
